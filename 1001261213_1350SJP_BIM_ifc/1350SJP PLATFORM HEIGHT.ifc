Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-10-29T10:20:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Alternate UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 29 10:20:28 2020 * Host: CHTSW00356 * Database: C:\Users\174558\AppData\Local\Temp\{AD5BD0CA-332F-407A-A54C-DB3B8D677A0E}\ifc * Database version: 5507 * Database creation date: Thu Oct 29 10:20:21 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 29 10:20:21 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 29 10:20:21 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcTransportElement: Height=41.30m(135'-6")_Reach=8.81m(28'-11")_230Kg(500lbs), 1001261213_1350SJP:Height=41.30m(135'-6")_Reach=8.81m(28'-11")_230Kg(500lbs):581935
In: Level 1
Type - Material: JLG_Plastic_Blue, JLG_Plastic_Green, JLG_Paint_Black, JLG_Plastic_Yellow, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_White, JLG_Paint_Orange, JLG_Paint_Silver Grey, JLG_Paint_Beige, JLG_Rubber_Black, JLG_Steel
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG -Telescopic boom lifts; Manufacturer: JLG; ProductionYear: n/a
